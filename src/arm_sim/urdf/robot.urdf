Commit message: control

File: src/arm_sim/urdf/robot.urdf (robot description, URDF)
Before this commit: robot my_robot, 11 links, 10 joints
Links:
- added link ee_link
Joints:
- added joint ee_fixed: type fixed, parent link2, child ee_link, origin xyz=0 0 0.265 rpy=0 0 0
